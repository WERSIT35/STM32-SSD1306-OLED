# Keil uVision project ssd1306.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ssd1306
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c delay.c delay.h ssd1306.h ssd1306.c
software components: CMSIS:CORE 6.1.0, Device:STM32Cube HAL:COMMON 1.12.2, Device:STM32Cube HAL:CORTEX 1.12.2, Device:STM32Cube HAL:DMA 1.12.2, Device:STM32Cube HAL:FLASH 1.12.2, Device:STM32Cube HAL:GPIO 1.12.2, Device:STM32Cube HAL:I2C 1.12.2, Device:STM32Cube HAL:PWR 1.12.2, Device:STM32Cube HAL:RCC 1.12.2, Device:Startup 1.12.2
